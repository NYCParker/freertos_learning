# Keil uVision project RTOSDemo.uvprojx, settings and files
target RTOSDemo - XMC4500 (ARM-ADS)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvkdm PART_XMC4500
  c misc: --cpu Cortex-M4.fp --no_allow_fpreg_for_nonfpdata
  c include: ..\CORTEX_M4F_Infineon_XMC4000_Keil;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM4F;..\Common\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry=Reset_Handler
  group Startup
    ./: startup_XMC4500.s System_XMC4500.c startup_XMC4200.s system_XMC4200.c system_XMC4400.c startup_XMC4400.s
  group Demo_Source
    ./: main.c FreeRTOSConfig.h RegTest.c main_full.c main_blinky.c
  group FreeRTOS_Source
    ../../Source/: timers.c list.c queue.c tasks.c
    ../../Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Source/portable/MemMang/: heap_4.c
  group Common_Demo_Source
    ../Common/Minimal/: semtest.c sp_flop.c blocktim.c countsem.c dynamic.c GenQTest.c recmutex.c
target RTOSDemo - XMC4400 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4400-F100x512 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x1FFFC000,0x4000) IROM(0x08000000,0x80000) IROM2(0x0C000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvkdm PART_XMC4400
  c misc: --cpu Cortex-M4.fp --no_allow_fpreg_for_nonfpdata
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  link misc: --entry=Reset_Handler
target RTOSDemo - XMC4200 (ARM-ADS)
  device: XMC4200-F64x256 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IRAM(0x20000000,0x5FC0) IRAM2(0x1FFFC000,0x4000) IROM(0x08000000,0x40000) IROM2(0x0C000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: v6Lang=1 v6LangP=1
  c define: rvkdm PART_XMC4200
  c misc: --cpu Cortex-M4.fp --no_allow_fpreg_for_nonfpdata
  c include: ..\CORTEX_M4F_Infineon_XMC4500_Keil;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM4F;..\Common\include;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0xc000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5fc0
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.1.2
