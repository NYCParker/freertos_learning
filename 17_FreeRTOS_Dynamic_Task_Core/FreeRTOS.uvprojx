# Keil uVision project FreeRTOS.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4400-F100x512 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x1FFFC000,0x4000) IROM(0x08000000,0x80000) IROM2(0x0C000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DEMO
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Peripherals_Drive;.\SYSTEM;.\FreeRTOS\port\RVDS\ARM_CM4F;.\FreeRTOS\include;.\Main;.\RTE\Device\XMC4400-F100x512
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  group Main
    ./Main/: main.c
  group Peripherals_Drive
    ./Peripherals_Drive/: GPIO.c USIC.c
  group System
    ./SYSTEM/: Var_Init.c Irq_Handle.c User_Func.c Sys_Task.c FreeRTOSConfig.h
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ./FreeRTOS/port/MemMang/: heap_4.c
    ./FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group README
    ./: README.txt
software components: CMSIS:CORE 5.1.2, Device:RTE_Device 1.1.0, Device:Startup 2.2.0, Device:XMClib:DAC 2.1.18, Device:XMClib:GPIO 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:UART 2.1.18
